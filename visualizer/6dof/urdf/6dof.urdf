Commit message: camera work maybe

File: visualizer/6dof/urdf/6dof.urdf (robot description, URDF)
Before this commit: robot GEN3_LITE_6DOF_WITH_GRIPPER, 14 links, 13 joints
Links:
- link WORKSPACE_INDICATOR: geometry visual box size=1.6 1.6 0.6
